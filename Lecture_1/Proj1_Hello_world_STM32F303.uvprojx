# Keil uVision project Proj1_Hello_world_STM32F303.uvprojx, settings and files
target Hello world (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Proj1_Hello_world_STM32F303
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Lib;.\CMSIS\Include;.\STM32F30x_StdPeriph_Driver\src;.\STM32F30x_StdPeriph_Driver\inc;.\CMSIS\Lib\ARM;.\CMSIS\Device\ST\STM32F30x\Source\Templates\arm;.\CMSIS\Device\ST\STM32F30x\Include;..\..\Data_for_lecture1\GL_EmbeddedProCamp\Lecture_1\Exercise_1\BlinkExample\Application;..\..\Data_for_lecture1\GL_EmbeddedProCamp\Lecture_1\Exercise_1\BlinkExample\STM32F30x_DSP_StdPeriph_Lib_V1.2.3\Libraries\STM32F30x_StdPeriph_Driver\src;..\..\Data_for_lecture1\GL_EmbeddedProCamp\Lecture_1\Exercise_1\BlinkExample\STM32F30x_DSP_StdPeriph_Lib_V1.2.3\Libraries\STM32F30x_StdPeriph_Driver\inc;.\CMSIS\Device\ST\STM32F30x\Include;.\CMSIS\Device\ST\STM32F30x\Source\Templates\arm
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application
    ../../Data_for_lecture1/GL_EmbeddedProCamp/Lecture_1/Exercise_1/BlinkExample/Application/: stm32f30x_it.c system_stm32f30x.c main.c
  group Library
    ../../Data_for_lecture1/GL_EmbeddedProCamp/Lecture_1/Exercise_1/BlinkExample/STM32F30x_DSP_StdPeriph_Lib_V1.2.3/Libraries/STM32F30x_StdPeriph_Driver/inc/: stm32f30x_gpio.h stm32f30x_rcc.h stm32f30x_tim.h stm32f30x_misc.h
    ../../Data_for_lecture1/GL_EmbeddedProCamp/Lecture_1/Exercise_1/BlinkExample/STM32F30x_DSP_StdPeriph_Lib_V1.2.3/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_tim.c stm32f30x_misc.c
  group CMSIS
    ./CMSIS/Include/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ./CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
    ./CMSIS/Device/ST/STM32F30x/Include/: stm32f30x.h
